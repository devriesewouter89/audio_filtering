# Keil uVision project audio_recog.uvprojx, settings and files
target Audio_DSP (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: audio_recog
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Utilities\STM32F4-Discovery;..\Libraries\CMSIS\ST\Include;..\Libraries\CMSIS\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\Libraries\tm_std32f4\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./src/: dsp.c gui_interface_communications.c headphone.c main.c microphone.c stm32f4xx_it.c system_stm32f4xx.c datalogging.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_pwr.c stm32f4xx_adc.c
    ../Utilities/STM32F4-Discovery/: libPDMFilter_Keil.lib
  group STM32F4-Discovery
    ../Utilities/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_audio_codec.c
  group CMSIS
    ../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group MDK-ARM
    ../Libraries/CMSIS/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group TM_STM32F4
    ../Libraries/tm_std32f4/src/: tm_stm32f4_delay.c tm_stm32f4_gpio.c tm_stm32f4_hd44780.c tm_stm32f4_rtc.c tm_stm32f4_timer_properties.c tm_stm32f4_adc.c
